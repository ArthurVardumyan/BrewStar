<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BrewStar.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BrewStar</name>
      <member>
        <project>BrewStar</project>
        <configuration>BrewStar</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


